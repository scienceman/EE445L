# Keil uVision project Lab10_xbee.uvproj, settings and files
target PeriodicTimer0AInts (ARM-ADS)
  device: LM3S1968 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: Lab10_xbee
  c flags: Optim=1
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Code
    ./: Startup.s system.c Output.c rit128x96x4.c UART.c Xbee.c lab10_xbeeMain.c
  group Library
    ../driverlib/rvmdk/: driverlib.lib
