# Keil uVision project Lab5_SPI.uvproj, settings and files
target PeriodicTimer0AInts (ARM-ADS)
  device: LM3S1968 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: Lab5_SPI
  c flags: Optim=1
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Code
    ./: Startup.s main_Lab5DAC.c music.c rit128x96x4.c system.c Output.c TimerCtrl.c
  group Library
    ../driverlib/rvmdk/: driverlib.lib
