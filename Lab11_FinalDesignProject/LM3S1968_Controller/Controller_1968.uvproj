# Keil uVision project Controller_1968.uvproj, settings and files
target ADC_TwoChan (ARM-ADS)
  device: LM3S1968 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: Controller_1968
  c flags: Optim=1
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Code
    ./: Startup.s line.c logo.c Output.c rit128x96x4.c system.c TimerCtrl.c UART.c Xbee.c Controller_Main.c ADC_Driver.c
  group Lib
    ../../driverlib/rvmdk/: driverlib.lib
