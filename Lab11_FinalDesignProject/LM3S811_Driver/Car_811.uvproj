# Keil uVision project Car_811.uvproj, settings and files
target SSR (ARM-ADS)
  device: LM3S811 Luminary Micro
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0xFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: SSR
  c flags: Optim=1
  c define: PART_LM3S811
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Code
    ./: Startup.s main_drivers.c motor_driver.c system.c TimerCtrl.c Xbee.c Sonar.c UART.c
  group New Group
    ../../driverlib/rvmdk/: driverlib.lib
